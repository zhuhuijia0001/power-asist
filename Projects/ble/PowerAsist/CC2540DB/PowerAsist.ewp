# IAR project PowerAsist.ewp, settings and files
configuration CC2540 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES=FALSE; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=TRUE; HAL_UART=TRUE; HAL_ADC=TRUE; DEBUG_PRINT; xUSE_CC_DEBUG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\Source; ..\Source\drv; ..\Source\menu; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540-UBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_UBL_MSD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2900; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=TRUE; HAL_UART=TRUE; DEBUG_PRINT; USE_CC_DEBUG
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-UBL\Exe\PowerAsistCC2540-UBL"
  XLINK.XclFile: cc254x_f256_ubl_msd.xcl
configuration CC2540-SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: OAD_KEEP_NV_PAGES; MAKE_CRC_SHDW; FEATURE_SBL; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=TRUE; HAL_UART=FALSE; xDEBUG_PRINT; xUSE_CC_DEBUG
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-SBL\Exe\PowerAsistCC2540-SBL"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_sbl.xcl
configuration CC2540-release (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES=FALSE; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=TRUE; HAL_UART=FALSE; HAL_ADC=TRUE; xDEBUG_PRINT; xUSE_CC_DEBUG
  ICC8051.CCOptLevel: 3
  group APP
    ../Source/: Calibration.c Calibration.h Global.c Global.h GUI.c GUI.h OSAL_PowerAsist.c Packet.c Packet.h Parameter.c Parameter.h peripheral_small.c PowerAsist.c PowerAsist.h PowerAsist_Main.c Protocol.h RealTimeData.c RealTimeData.h
  group driver
    ../Source/drv/: AutoDetect.c AutoDetect.h Delay.c Delay.h Detect.c Detect.h EEPROM.h EEPROMConfig.h FM24Cxx.c FM24Cxx.h FUSB302.c FUSB302.h I2C.c I2C.h I2CDevice.c I2CDevice.h INA226.c INA226.h ISL1208.c ISL1208.h LCD.c LCD.h Meter.c Meter.h QuickCharge.c QuickCharge.h RTC.c RTC.h UsbPd.c UsbPd.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group menu
    ../Source/menu/: draw.c draw.h menu.c menu.h menuAutoDetect.c menuBle.c menuBleComm.c menuCali.c menuCurrentCali.c menuDetail.c menuLock.c menuMain.c menuMessage.c menuMessage.h menuOp.h menuPD.c menuPDList.c menuQC20.c menuQC30.c menuSample.c menuScreen.c menuSetting.c menuSleep.c menuSniffer.c menuTime.c menuVersion.c menuVoltageCali.c menuWelcome.c Strings.h
  group NPI
    ../../common/npi/npi_np/: npi.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: gap.c
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/SimpleProfile/: powerAsistGATTprofile.c powerAsistGATTprofile.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
